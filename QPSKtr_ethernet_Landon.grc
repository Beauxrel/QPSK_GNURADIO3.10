options:
  parameters:
    author: Manolis Bozis
    comment: |-
      works in GNU Radio Companion 3.7.13.5
      in windows 7 system
    generate_options: qt_gui
    id: QPSK_transmitter
    output_language: python
    title: QPSK Transmitter with differential coding
  states: {}

blocks:
- name: Carrier_Frequency
  id: variable
  parameters:
    value: 735e6
  states: {}
- name: Const_Pnts
  id: variable
  parameters:
    value: epy_module_0.PSKsymbols(Mod_Ind)
  states: {}
- name: Delay
  id: variable
  parameters:
    value: int((Taps_No-1)/2)
  states: {}
- name: Mod_Ind
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Points
  id: variable
  parameters:
    value: '10'
  states: {}
- name: QPSK
  id: variable_constellation
  parameters:
    const_points: Const_Pnts
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: Mod_Ind
    sym_map: Symbol_Map
    type: calcdist
  states: {}
- name: RC_Delay
  id: variable
  parameters:
    value: sps-(2*Delay+1)%sps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: Symbol_Map
  id: variable
  parameters:
    value: epy_module_1.gray2int( int( math.log(Mod_Ind, 2.0) ) )
  states: {}
- name: Taps_No
  id: variable
  parameters:
    value: '31'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: cutoff
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: cutoff
    start: '0.0'
    step: '1000'
    stop: '100000'
    value: '1000'
  states: {}
- name: frequency_offset
  id: variable_qtgui_range
  parameters:
    label: frequency_offset
    start: '0.0'
    step: '10e-9'
    stop: '1e-5'
    value: '0.0'
  states: {}
- name: message_bytes
  id: variable
  parameters:
    value: '44153'
  states: {}
- name: message_length
  id: variable
  parameters:
    value: 44153*8
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0.0'
    step: '0.005'
    stop: '0.2'
    value: '0.0'
  states: {}
- name: preample_length
  id: variable
  parameters:
    value: 2*8
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,1
    label: squelch
    start: '-200'
    step: '5'
    stop: '-10'
    value: '-10'
  states: {}
- name: timing_offset
  id: variable_qtgui_range
  parameters:
    label: timing offset
    start: '1.0'
    step: '1e-6'
    stop: '1.001'
    value: '1.0'
  states: {}
- name: transition
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: transition
    start: '0.0'
    step: '100'
    stop: '10000'
    value: '100'
  states: {}
- name: var_const
  id: variable_constellation
  parameters:
    const_points: Const_Pnts
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: Mod_Ind
    sym_map: Symbol_Map
    type: calcdist
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: sps
    reference: '2'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: byte
  states: {}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\Landon\Desktop\Landon\QPSK\rx\TXTout.txt
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Landon\Desktop\Landon\QPSK\tx\text_send.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: message_length
    n: message_length+preample_length
    offset: '0'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: int(math.log(Mod_Ind, 2))
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '1'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (16, 488)
    type: byte
  states: {}
- name: blocks_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: burst
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,1,1,0,0,0,0,1,0,1,0,1,1,0,1,0,1,1,1,0,1,0,0,0,1,0,0,1,0,0,1,1)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: timing_offset
    freq_offset: frequency_offset
    noise_voltage: noise
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: Const_Pnts
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '11100001010110101110100010010011'
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_1
  id: digital_costas_loop_cc
  parameters:
    order: Mod_Ind
    w: 2*math.pi/100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: Mod_Ind
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: Mod_Ind
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '.0628'
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: firdes.root_raised_cosine(32, 32*sps, 1.0,alpha,sps*11*32)
    type: ccf
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      # Returns a vector with the M-PSK complex symbols
      # M: Modulation index (M=2: BPSK, M=4: QPSK, etc)

      import numpy
      import cmath

      def PSKsymbols(M):
          if M==2:
             return [1, -1]
          else:
             lst = numpy.arange(M)
             return numpy.exp( (lst * 2j +1j) * cmath.pi/M )
  states: {}
- name: epy_module_1
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      # Returns a vector of a decimal set of Gray codes of n binary digits
      # n: The binary digits length of the Gray code

      def gray_code(n):
          if n <= 0:
              return []
          if n == 1:
              return ['0', '1']
          res = gray_code(n-1)
          return ['0'+s for s in res] + ['1'+s for s in res[::-1]]

      def bin_to_gray(n):
          if n == 0:
              return 0
          if n == 1:
              return 1
          a = MSB(n) # Assume MSB function exists. It find MSB of n
          b = n - 2**a
          return 2**a + bin_to_gray(2**a-1-b)

      import math
      # A simple way to find MSB
      def MSB(n):
          return int( math.log(n, 2.0) )

      def gray2int(n):
          A = []
          for k in range(2**n):
              A.append(bin_to_gray(k))
          return A
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '5.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.50.236
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: '70'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.50.236
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"QPSK Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    name: Rx Constellation Diagram Sync
    size: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: float(samp_rate*sps)
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: Points
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: sps*Points
    srate: samp_rate
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    gain: '1'
    interp: sps
    ntaps: Taps_No
    samp_rate: Rs*sps
    sym_rate: Rs
    type: interp_fir_filter_ccf
  states: {}

connections:
- [analog_feedforward_agc_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_feedforward_agc_cc_0, '0']
- [blocks_burst_tagger_0, '0', blocks_tagged_stream_align_0, '0']
- [blocks_char_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_file_source_0_0, '0', blocks_stream_mux_0, '1']
- [blocks_keep_m_in_n_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_throttle2_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_stream_to_streams_0, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_stream_mux_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_stream_to_streams_0, '0', blocks_burst_tagger_0, '0']
- [blocks_stream_to_streams_0, '1', blocks_char_to_short_0, '0']
- [blocks_tag_gate_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_tag_gate_0, '0']
- [blocks_throttle2_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', blocks_file_sink_0_0_1, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [channels_channel_model_0, '0', iio_pluto_sink_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_costas_loop_cc_1, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_1, '0', qtgui_const_sink_x_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', analog_simple_squelch_cc_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [root_raised_cosine_filter_0, '0', channels_channel_model_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
